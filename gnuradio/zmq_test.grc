options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: zmq_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: baud_byte
  id: variable
  parameters:
    value: baud_bit/8
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159*(fsk_dev/(baud_bit*spsym))
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:4321
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_socket_pdu_1, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_unpacked_to_packed_xx_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
