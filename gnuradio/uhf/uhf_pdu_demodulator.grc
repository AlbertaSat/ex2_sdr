options:
  parameters:
    author: Josh Lazaruk, Steven Knudsen
    category: '[AlbertaSat]'
    copyright: AlbertaSat 2022-20xx
    description: The basic UHF demodulation block to match the EnduroSat II radio
    generate_options: hb
    id: uhf_pdu_demodulate
    output_language: python
    title: UHF PDU Demodulate
  states: {}

blocks:
- name: fm_freq_dev
  id: variable
  parameters:
    value: fm_modulation_index*baud_rate/2
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: oversample_rate
  id: variable
  parameters:
    value: '8.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: fm_samples_per_symbol*baud_rate
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(fm_samples_per_symbol),0.35,11*fm_samples_per_symbol*nfilts)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Made QDemod Gain an if-then-else
      stmt to avoid div by zero
    gain: samp_rate/(2*math.pi*fm_freq_dev) if fm_freq_dev > 0 else samp_rate/(2*math.pi)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: range is [-50, 50] dB
    threshold: squelch_threshold
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud
    type: eng_float
    value: '0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: packet_sync_word
    tagname: FS
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.5'
    max_dev: '0.005'
    osps: '1'
    sps: fm_samples_per_symbol
    taps: taps
    type: fff
  states: {}
- name: fm_modulation_index
  id: parameter
  parameters:
    label: FM Modulation Index
    type: eng_float
    value: '0'
  states: {}
- name: fm_samples_per_symbol
  id: parameter
  parameters:
    label: FM Samples per Symbol
    type: intx
    value: '256'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: Unpacked
  states: {}
- name: packet_sync_word
  id: parameter
  parameters:
    label: Packet Sync (unpacked binary)
    type: str
    value: '''0111111010000000'''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdus
    type: message
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: raw_f
    type: float
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: raw_b
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_nominal_length
  id: parameter
  parameters:
    label: Nominal PDU length (bytes)
    type: intx
    value: '128'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: pdu_nominal_length
    sync: packet_sync_word
    threshold: int(len(packet_sync_word)/8)
  states: {}
- name: squelch_threshold
  id: parameter
  parameters:
    label: Squelch Threshold [-50, 50] dB
    type: eng_float
    value: '-30'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', satellites_fsk_demodulator_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', pad_sink_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', pad_sink_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', pad_sink_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', satellites_ax25_deframer_0, '0']
- [pad_source_0, '0', analog_simple_squelch_cc_0, '0']
- [satellites_ax25_deframer_0, out, pad_sink_0, in]
- [satellites_fsk_demodulator_0, '0', pad_sink_0_0_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, pad_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
