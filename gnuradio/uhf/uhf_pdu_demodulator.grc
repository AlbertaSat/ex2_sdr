options:
  parameters:
    author: Josh Lazaruk, Steven Knudsen
    category: '[AlbertaSat]'
    copyright: AlbertaSat 2022-20xx
    description: The basic UHF demodulation block to match the EnduroSat II radio
    generate_options: hb
    id: uhf_pdu_demodulate
    output_language: python
    title: UHF PDU Demodulate
  states: {}

blocks:
- name: fm_freq_dev
  id: variable
  parameters:
    value: fm_modulation_index*baud_rate/2
  states: {}
- name: fm_samples_per_symbol
  id: variable
  parameters:
    value: '256'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: oversample_rate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(fm_samples_per_symbol/oversample_rate),0.35,int(11*fm_samples_per_symbol/oversample_rate*nfilts))
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fm_freq_dev) if fm_freq_dev > 0 else samp_rate/(2*math.pi)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud rate
    type: eng_float
    value: '0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.5'
    max_dev: '0.005'
    osps: '1'
    sps: fm_samples_per_symbol/oversample_rate
    taps: taps
    type: fff
  states: {}
- name: fm_modulation_index
  id: parameter
  parameters:
    label: FM Modulation Index
    type: eng_float
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: Unpacked
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Made QDemod Gain an if-then-else stmt to avoid div by zero
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdus
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: fm_samples_per_symbol*baud_rate
    fbw: '0.4'
    interp: int(fm_samples_per_symbol/oversample_rate*baud_rate)
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    samp_rate: fm_samples_per_symbol/oversample_rate*baud_rate
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '128'
    sync: '''0111111010000000'''
    threshold: '0'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', satellites_fsk_demodulator_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [satellites_ax25_deframer_0, out, pad_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, pad_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
