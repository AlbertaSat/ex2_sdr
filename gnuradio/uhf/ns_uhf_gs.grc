options:
  parameters:
    author: AlbertaSat
    comment: |-
      Josh Lazaruk, 
      Hariharan Krishnan, 
      Thomas Ganley, 
      Steven Knudsen
    generate_options: qt_gui
    id: endurosat_e2e
    output_language: python
    realtime_scheduling: '1'
    title: NS UHF TRX
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '{es_mode == 0: 1200, es_mode==1: 2400, es_mode==2:4800,es_mode==3:9600,es_mode==4:9600}.get(True,19200)'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_rx
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_tx
  id: variable
  parameters:
    value: int(2*center_freq - center_freq_rx)
  states: {}
- name: data_rate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Data Rate
    type: int
    value: baud_bit
  states: {}
- name: es_mode
  id: variable
  parameters:
    comment: |-
      EnduroSat Mode
        = [0,1,2,3,4,5,6,7]

      Choose a value before
      running this flowgraph
    value: '3'
  states: {}
- name: es_mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'EnduroSat UHF II Mode : '
    type: int
    value: es_mode
  states: {}
- name: freq_dev_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Dev
    type: int
    value: fsk_dev
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '{es_mode == 0: 600, es_mode==1: 600, es_mode==2:1200,es_mode==3:2400,es_mode==4:4800,es_mode==5:4800,es_mode==6:9600}.get(True,19200)'
  states: {}
- name: in_len
  id: variable
  parameters:
    value: '158'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '{es_mode == 0: 1, es_mode==1: 0.5, es_mode==2:0.5,es_mode==3:0.5,es_mode==4:1,es_mode==5:0.5,es_mode==6:1}.get(True,2)'
  states: {}
- name: mod_index_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: Mod Index
    type: real
    value: mod_index
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: out_len
  id: variable
  parameters:
    value: '129'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Normalized gain value
      Gain (dB) = 76*rx_gain
    gui_hint: 'tab_id@0 : 0,0,1,5'
    label: rx_gain
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.6'
  states: {}
- name: rx_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab_id@0 : 1,0,1,5'
    label: rx_threshold
    start: '-80'
    step: '5'
    stop: '5'
    value: '-20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_bit*spsym
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*(fsk_dev/(baud_bit*spsym))
  states: {}
- name: sensitivity_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: FM Sensitivity
    type: real
    value: sensitivity
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(spsym),0.35,11*spsym*nfilts)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Normalized gain value
      Gain (dB) = 89.8*tx_gain
    gui_hint: 'tab_id@1 : 0,0,1,5'
    label: tx_gain
    start: '0'
    step: '0.05'
    stop: '0.6'
    value: '.4'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_dev)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: '*Needs to be tuned for flight'
    threshold: rx_threshold
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: TX set GPIO0 High
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 0x1, ''mask'': 0x1}))'
    period: '3000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    comment: All GPIOs to ATR Mode
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''CTRL'', ''value'': 0xFFFF, ''mask'': 0xFFFF}))'
    period: '2000'
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    comment: All GPIOs are outputs
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''DDR'', ''value'': 0xFFFF, ''mask'': 0xFFFF}))'
    period: '2200'
  states: {}
- name: blocks_message_strobe_0_1
  id: blocks_message_strobe
  parameters:
    comment: Idle (flowgraph not running) set all Low
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_0X'', ''value'': 0x00, ''mask'': 0xFF}))'
    period: '2400'
  states: {}
- name: blocks_message_strobe_0_1_0
  id: blocks_message_strobe
  parameters:
    comment: RX set GPIO0-3, 5-7 Low
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_RX'', ''value'': 0, ''mask'': 0xEF}))'
    period: '2800'
  states: {}
- name: blocks_message_strobe_0_1_1
  id: blocks_message_strobe
  parameters:
    comment: RX set GPIO4 High
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_RX'', ''value'': 0x10, ''mask'': 0x10}))'
    period: '2600'
  states: {}
- name: blocks_message_strobe_0_1_2
  id: blocks_message_strobe
  parameters:
    comment: TX set GPIO1 - GPIO7 Low
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 0xFE, ''mask'': 0xFE}))'
    period: '3200'
  states: {}
- name: blocks_message_strobe_0_1_4
  id: blocks_message_strobe
  parameters:
    comment: |-
      Full Duplex required when
      operating RX and TX, 
      so XX mode sets GPIO0 High
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_XX'', ''value'': 0x1, ''mask'': 0x1}))'
    period: '3400'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4322'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    comment: UHF Direct Commands
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    comment: CSP Data
    host: 127.0.0.1
    mtu: '10000'
    port: '1235'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: fsk_dev
    target: fsk_dev
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: baud_bit
    target: baud_bit
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq_rx
    target: center_freq_rx
  states: {}
- name: blocks_var_to_msg_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq_tx
    target: center_freq_tx
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: Output is unpacked
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.25'
    comment: GFSK Mod input is packed bytes (eg. 0b01110000)
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100
    max_dev: '0.005'
    osps: '1'
    sps: spsym
    taps: taps
    type: fff
  states: {}
- name: gpredict_doppler
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nfrom gnuradio import gr\nimport threading\nimport time\nimport socket\n\nclass doppler_runner(threading.Thread):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    threading.Thread.__init__(self)\n\n    self.callback = callback\n    self.gpredict_host = gpredict_host\n    self.gpredict_port = gpredict_port\n    self.freq = freq\n\n\n  def run(self):\n    #bind_to = (self.gpredict_host, self.gpredict_port)\n    bind_to = ('127.0.0.1', 4532)\n    server = socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n    print(bind_to)\n    server.bind(bind_to)\n    server.listen(0)\n\n    time.sleep(0.5) # TODO: Find better way to know if init is all done\n\n    while True:\n      print(\"Waiting for connection on: %s:%d\" % bind_to)\n      sock, addr = server.accept()\n      print(\"Connected from: %s:%d\" % (addr[0], addr[1]))\n\n      cur_freq = 0\n      while True:\n        data = sock.recv(1024)\n        if not data:\n          break\n\n        if data.startswith(b'F'):\n          self.freq = int(data[1:].strip())\n          if cur_freq != self.freq:\n            print(\"New frequency: %d\" % self.freq)\n            self.callback(self.freq)\n            cur_freq = self.freq\n          sock.sendall(b'RPRT 0\\n')\n        elif data.startswith(b'f'):\n          sock.sendall(b'f: %d\\n' % cur_freq)\n\n      sock.close()\n      print(\"Disconnected from: %s:%d\" % (addr[0], addr[1]))\n\n    #sys.exit()\n\nclass doppler(gr.sync_block):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    gr.sync_block.__init__(self,\n                           name = \"Gpredict Doppler\",\n                           in_sig = None,\n                           out_sig = None)\n    doppler_runner(callback, freq, gpredict_host, gpredict_port).start()\n\n"
  states: {state: disabled}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq_rx
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*2
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: 1024*4
    grid: 'True'
    gui_hint: 'tab_id@0 : 2,2,3,3'
    name: Receive FFT
    type: complex
    update_time: '0.05'
    ymax: rx_threshold
    ymin: rx_threshold-80
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*2
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: 1024*4
    grid: 'True'
    gui_hint: 'tab_id@1 : 1,0,1,5'
    name: Transmit FFT
    type: complex
    update_time: '0.05'
    ymax: '30'
    ymin: '-80'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 2*baud_bit*spsym
    fc: '437875000'
    fftsize: 1024*10
    gui_hint: 'tab_id@0 : 2,0,3,2'
    name: '"Receive Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_bit
    iq: 'True'
    samp_rate: spsym*baud_bit
    subaudio: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '128'
    sync: '''0111111010000000'''
    threshold: '0'
  states: {}
- name: tab_id
  id: qtgui_tab_widget
  parameters:
    label0: RX
    label1: TX
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq_tx
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq_rx
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_message_strobe_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_0_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_1, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_1_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_1_1, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_1_2, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_1_4, strobe, uhd_usrp_sink_0, command]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_socket_pdu_1, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_socket_pdu_1_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0_0, msgout, blocks_message_debug_0, print]
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0_0, pdus]
- [satellites_ax25_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_hexdump_sink_0, in]
- [uhd_usrp_source_0_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
