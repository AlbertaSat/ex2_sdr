options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: udp_test_del_me
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}

connections:
- [blocks_socket_pdu_1, pdus, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
