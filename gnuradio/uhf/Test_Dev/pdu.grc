options:
  parameters:
    author: J. Gilbert
    copyright: 2021 J. Gilbert
    description: Example usage of a range of PDU tools.
    generate_options: qt_gui
    id: pdu_tools_demo
    output_language: python
    title: PDU Tools Example
  states: {}

blocks:
- name: interval
  id: variable
  parameters:
    value: '0.400'
  states: {}
- name: timekey
  id: variable
  parameters:
    value: pmt.intern("SYS_TIME")
  states: {state: disabled}
- name: val
  id: variable_qtgui_range
  parameters:
    label: KEY1 Metadata Value
    start: '0'
    step: '0.1'
    stop: '500.0'
    value: '123.4'
  states: {}
- name: add_sys_time
  id: pdu_add_system_time
  parameters:
    comment: |-
      This block will add the system
      time to the PDU metadata as a
      double precision float. The time
      key can be set by the user.
    key: timekey
  states: {state: disabled}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("KEY1")
    v: pmt.from_double(val)
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '10'
    minsize: '10'
  states: {}
- name: msg_dbg
  id: blocks_message_debug
  parameters:
    comment: Print out the metadata dictionary.
  states: {state: disabled}
- name: msg_dbg_0
  id: blocks_message_debug
  parameters:
    comment: Print out the metadata dictionary.
  states: {}
- name: msg_strobe
  id: blocks_message_strobe
  parameters:
    comment: Emits pmt.PMT_T
    msg: pmt.PMT_T
    period: int(interval*1000)
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      Normally, some PDU processing
      would be done here for the time
      benchmarks to be applied over.
    note: README
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      This flowgraph highlights a number of useful PDU tools together.
      This flowgraph is not intended to do anything particularly useful
      other than serve as a reference / demonstration.
    note: SUMMARY
  states: {}
- name: pdu_split
  id: pdu_pdu_split
  parameters:
    comment: |-
      The PDU will be split into its metadata dictionary
      and uniform vector, which will then be emitted as
      dict/uvec PMT messages respectively.
    pass_empty: 'False'
  states: {state: disabled}
- name: time_delta
  id: pdu_time_delta
  parameters:
    comment: |-
      This block calculates the ms that have 
      elapsed between when the time key
      was added and now, and print statistics
      when the flowgraph stops.
    delta_key: pmt.intern("time_delta_ms")
    time_key: timekey
  states: {state: disabled}
- name: time_raster
  id: qtgui_time_raster_sink_x
  parameters:
    comment: Colors for fun.
    name: '"This Plot Is Not Meaningful"'
    ncols: '128'
    samp_rate: '1'
    type: msg_byte
    zmax: '127'
    zmin: '-128'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '122'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '122'
  states: {}
- name: vs2
  id: virtual_sink
  parameters:
    stream_id: y
  states: {state: disabled}
- name: vs3
  id: virtual_source
  parameters:
    stream_id: y
  states: {state: disabled}

connections:
- [add_sys_time, pdu, time_delta, pdu]
- [blocks_pdu_set_0, pdus, virtual_sink_0, '0']
- [blocks_random_pdu_0, pdus, blocks_pdu_set_0, pdus]
- [msg_strobe, strobe, blocks_random_pdu_0, generate]
- [pdu_split, dict, msg_dbg, print]
- [pdu_split, vec, time_raster, in]
- [time_delta, pdu, vs2, '0']
- [virtual_source_0, '0', msg_dbg_0, print_pdu]
- [vs3, '0', pdu_split, pdu]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
