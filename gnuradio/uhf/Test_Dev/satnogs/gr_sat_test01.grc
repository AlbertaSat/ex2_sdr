options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: gr_sat_test01
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/knud/Development/AlbertaSat/ex2_sdr/gnuradio/uhf/Test_Dev/satnogs/BISON1.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/knud/Development/AlbertaSat/ex2_sdr/gnuradio/uhf/Test_Dev/satnogs/BISON1.wav
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: float
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: /home/knud/Development/AlbertaSat/ex2_sdr/gnuradio/uhf/Test_Dev/satnogs/BISONSAT.yml
    name: BISONSAT
    norad: '40968'
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /home/knud/Development/AlbertaSat/ex2_sdr/gnuradio/uhf/Test_Dev/satnogs/AURORASAT.yml
    norad: '99169'
    samp_rate: samp_rate
  states: {state: disabled}

connections:
- [blocks_wavfile_source_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0_0, '0', satellites_satellite_decoder_0_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print]
- [satellites_satellite_decoder_0_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
