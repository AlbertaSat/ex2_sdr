options:
  parameters:
    author: Steven Knudsen
    generate_options: qt_gui
    id: raw_satnogs_read
    output_language: python
    title: Raw SatNogs read
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/knud/Development/AlbertaSat/ex2_sdr/gnuradio/uhf/Test_Dev/satnogs/satnogs_7663458_2023-06-03T20-58-52_BISONSAT.raw
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/knud/Development/AlbertaSat/ex2_sdr/gnuradio/uhf/Test_Dev/satnogs/BISON2.wav
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: samp_rate*5
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '15400'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '3'
    fc: '0'
    fftsize: '512'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    name: BISONSAT
    norad: '40968'
    samp_rate: samp_rate
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_wavfile_source_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
