options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: pdu_gen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: packet_len
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.make_u8vector(10, 0))
    period: '1000'
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("key")
    v: pmt.intern("value")
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '10'
    minsize: '10'
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_copy_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_message_strobe_0, strobe, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_pdu_set_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_copy_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_random_pdu_0, pdus, blocks_pdu_set_0, pdus]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
