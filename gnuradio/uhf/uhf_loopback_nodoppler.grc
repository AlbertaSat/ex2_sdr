options:
  parameters:
    generate_options: qt_gui
    id: uhf_mode5_loopback_nodoppler
    output_language: python
    realtime_scheduling: '1'
    title: UHF Mode 5 Loopback no dopper
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: in_len
  id: variable
  parameters:
    value: '158'
  states: {}
- name: out_len
  id: variable
  parameters:
    value: '129'
  states: {}
- name: oversample_rate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_bit*spsym
  states: {}
- name: spsym
  id: variable
  parameters:
    value: spsym_frontend/oversample_rate
  states: {}
- name: spsym_frontend
  id: variable
  parameters:
    value: '256'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 1, ''mask'': ((1 << 11) - 1)}))'
    period: '10000'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''CTRL'', ''value'': 1, ''mask'': ((1 << 11) - 1)}))'
    period: '7000'
  states: {state: disabled}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''DDR'', ''value'': 1, ''mask'': ((1 << 11) - 1)}))'
    period: '8500'
  states: {state: disabled}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("key")
    v: pmt.intern("value")
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '2'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4322'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1235'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: fsk_dev
    target: fsk_dev
  states: {state: disabled}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: baud_bit
    target: baud_bit
  states: {state: disabled}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq
    target: center_freq
  states: {state: disabled}
- name: fm_sensitivity
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    name: '"FM Sensitivity"'
    type: float
    update_time: '1'
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: UHFDIR cmds
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: CSP Data
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int(spsym_frontend*50)*10
    srate: int(spsym_frontend*50)
    type: complex
    update_time: '1'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: int(baud_bit*spsym_frontend*5)
    srate: int(baud_bit*spsym_frontend*5)
    type: complex
    update_time: '5'
    ylabel: Raw
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '0'
    sync: '"00011010110011111111110000011101"'
    threshold: '4'
  states: {state: disabled}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '0'
    sync: '"00011010110011111111110000011101"'
    threshold: '4'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: baud_bit*spsym_frontend
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dev_args: '""'
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: baud_bit*spsym_frontend
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhf_pdu_demodulate_0
  id: uhf_pdu_demodulate
  parameters:
    baud_rate: baud_bit
    fm_modulation_index: '1'
    samp_rate: samp_rate
  states: {}
- name: uhf_pdu_modulate_0
  id: uhf_pdu_modulate
  parameters:
    fm_modulation_index: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: UHF_virt_01
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: UHF_virt_01
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {state: disabled}

connections:
- [blocks_message_strobe_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_0_0, strobe, uhd_usrp_sink_0, command]
- [blocks_socket_pdu_1, pdus, uhf_pdu_modulate_0, pdus]
- [blocks_socket_pdu_1_0, pdus, uhf_pdu_modulate_0, pdus]
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [uhd_usrp_source_0_0, '0', uhf_pdu_demodulate_0, '0']
- [uhf_pdu_demodulate_0, pdus, blocks_socket_pdu_0, pdus]
- [uhf_pdu_demodulate_0, pdus, blocks_socket_pdu_0_0, pdus]
- [uhf_pdu_demodulate_0, pdus, satellites_hexdump_sink_0, in]
- [uhf_pdu_modulate_0, '0', qtgui_time_sink_x_0, '0']
- [uhf_pdu_modulate_0, '0', uhd_usrp_sink_0, '0']
- [uhf_pdu_modulate_0, '0', virtual_sink_0, '0']
- [uhf_pdu_modulate_0, '1', fm_sensitivity, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', uhf_pdu_demodulate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
