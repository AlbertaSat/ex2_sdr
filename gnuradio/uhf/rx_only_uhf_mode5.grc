options:
  parameters:
    generate_options: qt_gui
    id: endurosat_e2e
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: baud_byte
  id: variable
  parameters:
    value: baud_bit/8
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159*(fsk_dev/(baud_bit*spsym))
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: note_0
  id: note
  parameters:
    note: Unpacked
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 256000*2
    srate: '256000'
    type: complex
    update_time: '2'
    ymax: '-1'
    ymin: '1'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_bit
    iq: 'True'
    samp_rate: spsym*baud_bit
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '129'
    sync: '''01111110'''
    threshold: '0'
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_args: '""'
    gain0: rx_gain
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: baud_bit*spsym
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_gfsk_demod_0, '0']
- [analog_simple_squelch_cc_0, '0', satellites_fsk_demodulator_0, '0']
- [digital_gfsk_demod_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_ax25_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_hexdump_sink_0, in]
- [uhd_usrp_source_0_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
