options:
  parameters:
    generate_options: qt_gui
    id: endurosat_e2e
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: baud_byte
  id: variable
  parameters:
    value: baud_bit/8
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_rx
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_tx
  id: variable
  parameters:
    value: int(center_freq + abs(center_freq - center_freq_rx))
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: in_len
  id: variable
  parameters:
    value: '158'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: out_len
  id: variable
  parameters:
    value: '129'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_bit*spsym
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159265358979323846*(fsk_dev/(baud_bit*spsym))
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(spsym),0.35,11*spsym*nfilts)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_dev)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 1, ''mask'': ((1 << 11) - 1)}))'
    period: '10000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''CTRL'', ''value'': 1, ''mask'': ((1 << 11) - 1)}))'
    period: '7000'
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''DDR'', ''value'': 1, ''mask'': ((1 << 11) - 1)}))'
    period: '8500'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4322'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1235'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: fsk_dev
    target: fsk_dev
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: baud_bit
    target: baud_bit
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq_rx
    target: center_freq_rx
  states: {}
- name: blocks_var_to_msg_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq_tx
    target: center_freq_tx
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.5'
    max_dev: '0.005'
    osps: '1'
    sps: spsym
    taps: taps
    type: fff
  states: {}
- name: gpredict_doppler
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nfrom gnuradio import gr\nimport threading\nimport time\nimport socket\n\nclass doppler_runner(threading.Thread):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    threading.Thread.__init__(self)\n\n    self.callback = callback\n    self.gpredict_host = gpredict_host\n    self.gpredict_port = gpredict_port\n    self.freq = freq\n\n\n  def run(self):\n    #bind_to = (self.gpredict_host, self.gpredict_port)\n    bind_to = ('127.0.0.1', 4532)\n    server = socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n    print(bind_to)\n    server.bind(bind_to)\n    server.listen(0)\n\n    time.sleep(0.5) # TODO: Find better way to know if init is all done\n\n    while True:\n      print(\"Waiting for connection on: %s:%d\" % bind_to)\n      sock, addr = server.accept()\n      print(\"Connected from: %s:%d\" % (addr[0], addr[1]))\n\n      cur_freq = 0\n      while True:\n        data = sock.recv(1024)\n        if not data:\n          break\n\n        if data.startswith(b'F'):\n          self.freq = int(data[1:].strip())\n          if cur_freq != self.freq:\n            print(\"New frequency: %d\" % self.freq)\n            self.callback(self.freq)\n            cur_freq = self.freq\n          sock.sendall(b'RPRT 0\\n')\n        elif data.startswith(b'f'):\n          sock.sendall(b'f: %d\\n' % cur_freq)\n\n      sock.close()\n      print(\"Disconnected from: %s:%d\" % (addr[0], addr[1]))\n\n    #sys.exit()\n\nclass doppler(gr.sync_block):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    gr.sync_block.__init__(self,\n                           name = \"Gpredict Doppler\",\n                           in_sig = None,\n                           out_sig = None)\n    doppler_runner(callback, freq, gpredict_host, gpredict_port).start()\n\n"
  states: {}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq_rx
  states: {}
- name: note_0
  id: note
  parameters:
    note: Unpacked
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: GFSK Mod input is packed bytes (eg. 0b01110000)
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Must have high sample rate for smooth sinusoid
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: UHFDIR cmds
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: CSP Data
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2*baud_bit*spsym
    fc: center_freq
    fftsize: 10*1024
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: spsym*50
    srate: spsym*50
    type: complex
    update_time: '1'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: baud_bit*spsym*5
    srate: baud_bit*spsym*5
    type: complex
    update_time: '5'
    ylabel: Raw
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: baud_bit*spsym*5
    srate: baud_bit*spsym*5
    type: complex
    update_time: '5'
    ylabel: Squelched
  states: {state: disabled}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_bit
    iq: 'True'
    samp_rate: spsym*baud_bit
    subaudio: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '128'
    sync: '''0111111010000000'''
    threshold: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq_tx
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: baud_bit*spsym
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq_rx
    dev_args: '""'
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:4321
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_message_strobe_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_0, strobe, uhd_usrp_sink_0, command]
- [blocks_message_strobe_0_0_0, strobe, uhd_usrp_sink_0, command]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_socket_pdu_1, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_socket_pdu_1_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0_0, msgout, blocks_message_debug_0, print]
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0_0, pdus]
- [satellites_ax25_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_hexdump_sink_0, in]
- [uhd_usrp_source_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [uhd_usrp_source_0_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_1, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
