options:
  parameters:
    author: Josh Lazaruk, Steven Knudsen
    category: '[AlbertaSat]'
    copyright: AlbertaSat 2022-20xx
    description: The basic UHF modulation block to match the EnduroSat II radio
    generate_options: hb
    id: uhf_pdu_modulate
    output_language: python
    title: UHF PDU Modulate
  states: {}

blocks:
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*3.14159265358979323846*(fsk_dev/(baud_bit*spsym_frontend))
  states: {state: disabled}
- name: sensitivity_tx_0
  id: variable
  parameters:
    value: 2*3.14159265358979323846*(fsk_dev/(baud_bit*spsym_frontend))
  states: {state: disabled}
- name: FSK_level
  id: parameter
  parameters:
    label: FSK Level (M)
    type: intx
    value: '2'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    comment: GFSK Mod input is packed bytes (eg. 0b01110000)
    log: 'True'
    samples_per_symbol: fm_samples_per_symbol
    sensitivity: math.pi*fm_modulation_index*(FSK_level - 1)/fm_samples_per_symbol
  states: {}
- name: fm_baud
  id: parameter
  parameters:
    label: Baud
    type: eng_float
    value: '1'
  states: {}
- name: fm_modulation_index
  id: parameter
  parameters:
    label: FM Modulation Index
    type: eng_float
    value: '0'
  states: {}
- name: fm_samples_per_symbol
  id: parameter
  parameters:
    label: FM Samples per Symbol
    type: eng_float
    value: '256'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdus
    type: message
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', pad_sink_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
