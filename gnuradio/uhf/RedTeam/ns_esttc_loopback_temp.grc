options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: ns_esttc_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_rx
  id: variable
  parameters:
    comment: |-
      Carrier frequency
      corrected for doppler
      shift by GPredict
    value: '437875000'
  states: {}
- name: center_freq_tx
  id: variable
  parameters:
    comment: |-
      Calculated Tx carrier
      frequency
    value: int(2 * center_freq - center_freq_rx)
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '{es_mode == 0: 1200, es_mode==1: 2400, es_mode==2:4800,es_mode==3:9600,es_mode==4:9600}.get(True,19200)'
  states: {}
- name: data_rate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Data Rate
    type: int
    value: data_rate
  states: {}
- name: es_mode
  id: variable
  parameters:
    comment: |-
      EnduroSat Mode
        = [0,1,2,3,4,5,6,7]

      Choose a value before
      running this flowgraph
    value: '5'
  states: {}
- name: es_mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'EnduroSat UHF II Mode : '
    type: int
    value: es_mode
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '{es_mode == 0: 600, es_mode==1: 600, es_mode==2:1200,es_mode==3:2400,es_mode==4:4800,es_mode==5:4800,es_mode==6:9600}.get(True,19200)'
  states: {}
- name: freq_dev_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Dev
    type: int
    value: freq_dev
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '{es_mode == 0: 1, es_mode==1: 0.5, es_mode==2:0.5,es_mode==3:0.5,es_mode==4:1,es_mode==5:0.5,es_mode==6:1}.get(True,2)'
  states: {}
- name: mod_index_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: Mod Index
    type: real
    value: mod_index
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '50'
  states: {}
- name: sensitivity_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: FM Sensitivity
    type: real
    value: sensitivity_tx
  states: {}
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*np.math.pi*(freq_dev/(data_rate*samples_per_symbol))
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(samples_per_symbol),0.35,11*samples_per_symbol*nfilts)
  states: {}
- name: taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(samples_per_symbol),0.35,int(11*samples_per_symbol*nfilts/4))
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshold
    start: '-50'
    step: '1'
    stop: '50'
    value: '-30'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*freq_dev)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.5'
    max_dev: '0.005'
    osps: '1'
    sps: samples_per_symbol
    taps: taps_0
    type: fff
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.5'
    max_dev: '0.005'
    osps: '1'
    sps: samples_per_symbol
    taps: taps_0
    type: fff
  states: {state: disabled}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq_rx
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Variables to be set
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated variables
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Unpacked
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    size: '200'
    srate: samp_rate
    stemplot: 'True'
    style1: '0'
    type: float
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '128'
    sync: '''01111110'''
    threshold: '0'
  states: {}
- name: uhf_pdu_modulate_0
  id: uhf_pdu_modulate
  parameters:
    FSK_level: '2'
    fm_baud: data_rate
    fm_modulation_index: mod_index
    fm_samples_per_symbol: samples_per_symbol
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_socket_pdu_1, pdus, blocks_message_debug_0_0, print_pdu]
- [blocks_socket_pdu_1, pdus, uhf_pdu_modulate_0, pdus]
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_message_debug_0_0_0, print]
- [uhf_pdu_modulate_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
