options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: ns_esttc_receiver_file_save
    output_language: python
    title: Northern SPIRIT Ground Station received signal read from file
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_rx
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_tx
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '{es_mode == 0: 1200, es_mode==1: 2400, es_mode==2:4800,es_mode==3:9600,es_mode==4:9600}.get(True,19200)'
  states: {}
- name: data_rate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Data Rate
    type: int
    value: data_rate
  states: {}
- name: es_mode
  id: variable
  parameters:
    comment: |-
      EnduroSat Mode
        = [0,1,2,3,4,5,6,7]

      Choose a value before
      running this flowgraph
    value: '4'
  states: {}
- name: es_mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'EnduroSat UHF II Mode : '
    type: int
    value: es_mode
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '{es_mode == 0: 600, es_mode==1: 600, es_mode==2:1200,es_mode==3:2400,es_mode==4:4800,es_mode==5:4800,es_mode==6:9600}.get(True,19200)'
  states: {}
- name: freq_dev_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Dev
    type: int
    value: freq_dev
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '{es_mode == 0: 1, es_mode==1: 0.5, es_mode==2:0.5,es_mode==3:0.5,es_mode==4:1,es_mode==5:0.5,es_mode==6:1}.get(True,2)'
  states: {}
- name: mod_index_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: Mod Index
    type: real
    value: mod_index
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sensitivity_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: FM Sensitivity
    type: real
    value: sensitivity_tx
  states: {}
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*np.math.pi*(freq_dev/(data_rate*samples_per_symbol))
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.dat
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4322'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1235'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: fsk_dev
    target: fsk_dev
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: baud_bit
    target: baud_bit
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq
    target: center_freq_rx
  states: {}
- name: blocks_var_to_msg_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq
    target: center_freq_tx
  states: {}
- name: gpredict_doppler
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nfrom gnuradio import gr\nimport threading\nimport time\nimport socket\n\nclass doppler_runner(threading.Thread):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    threading.Thread.__init__(self)\n\n    self.callback = callback\n    self.gpredict_host = gpredict_host\n    self.gpredict_port = gpredict_port\n    self.freq = freq\n\n\n  def run(self):\n    #bind_to = (self.gpredict_host, self.gpredict_port)\n    bind_to = ('127.0.0.1', 4532)\n    server = socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n    print(bind_to)\n    server.bind(bind_to)\n    server.listen(0)\n\n    time.sleep(0.5) # TODO: Find better way to know if init is all done\n\n    while True:\n      print(\"Waiting for connection on: %s:%d\" % bind_to)\n      sock, addr = server.accept()\n      print(\"Connected from: %s:%d\" % (addr[0], addr[1]))\n\n      cur_freq = 0\n      while True:\n        data = sock.recv(1024)\n        if not data:\n          break\n\n        if data.startswith(b'F'):\n          self.freq = int(data[1:].strip())\n          if cur_freq != self.freq:\n            print(\"New frequency: %d\" % self.freq)\n            self.callback(self.freq)\n            cur_freq = self.freq\n          sock.sendall(b'RPRT 0\\n')\n        elif data.startswith(b'f'):\n          sock.sendall(b'f: %d\\n' % cur_freq)\n\n      sock.close()\n      print(\"Disconnected from: %s:%d\" % (addr[0], addr[1]))\n\n    #sys.exit()\n\nclass doppler(gr.sync_block):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    gr.sync_block.__init__(self,\n                           name = \"Gpredict Doppler\",\n                           in_sig = None,\n                           out_sig = None)\n    doppler_runner(callback, freq, gpredict_host, gpredict_port).start()\n\n"
  states: {state: disabled}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq_rx
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Variables to be set
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated variables
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,3
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,3,1,2
    type: complex
  states: {state: disabled}
- name: uhf_pdu_modulate_0
  id: uhf_pdu_modulate
  parameters:
    FSK_level: '2'
    fm_baud: data_rate
    fm_modulation_index: mod_index
    fm_samples_per_symbol: samples_per_symbol
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_socket_pdu_1, pdus, uhf_pdu_modulate_0, pdus]
- [blocks_socket_pdu_1_0, pdus, uhf_pdu_modulate_0, pdus]
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0_0, msgout, blocks_message_debug_0, print]
- [uhf_pdu_modulate_0, '0', blocks_file_sink_0, '0']
- [uhf_pdu_modulate_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
