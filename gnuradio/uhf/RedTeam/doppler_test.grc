options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: doppler_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq_rx
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: center_freq_rx
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 437875000 - center_freq_rx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '4532'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import socket
      import time
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='gpredict listener',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              
              bind_to = ('127.0.0.1', 4532)
              server = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
              print(bind_to)
              server.bind(bind_to)
              server.listen(0)

              time.sleep(0.5)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: gpredict_doppler
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nfrom gnuradio import gr\nimport threading\nimport time\nimport socket\n\nclass doppler_runner(threading.Thread):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    threading.Thread.__init__(self)\n\n    self.callback = callback\n    self.gpredict_host = gpredict_host\n    self.gpredict_port = gpredict_port\n    self.freq = freq\n\n\n  def run(self):\n    #bind_to = (self.gpredict_host, self.gpredict_port)\n    bind_to = ('127.0.0.1', 4532)\n    server = socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n    print(bind_to)\n    server.bind(bind_to)\n    server.listen(0)\n\n    time.sleep(0.5) # TODO: Find better way to know if init is all done\n\n    while True:\n      print(\"Waiting for connection on: %s:%d\" % bind_to)\n      sock, addr = server.accept()\n      print(\"Connected from: %s:%d\" % (addr[0], addr[1]))\n\n      cur_freq = 0\n      while True:\n        data = sock.recv(1024)\n        if not data:\n          break\n\n        if data.startswith(b'F'):\n          self.freq = int(data[1:].strip())\n          if cur_freq != self.freq:\n            print(\"New frequency: %d\" % self.freq)\n            self.callback(self.freq)\n            cur_freq = self.freq\n          sock.sendall(b'RPRT 0\\n')\n        elif data.startswith(b'f'):\n          sock.sendall(b'f: %d\\n' % cur_freq)\n\n      sock.close()\n      print(\"Disconnected from: %s:%d\" % (addr[0], addr[1]))\n\n    #sys.exit()\n\nclass doppler(gr.sync_block):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    gr.sync_block.__init__(self,\n                           name = \"Gpredict Doppler\",\n                           in_sig = None,\n                           out_sig = None)\n    doppler_runner(callback, freq, gpredict_host, gpredict_port).start()\n\n"
  states: {state: disabled}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq_rx
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '4532'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0, print]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [network_udp_source_0, '0', blocks_tagged_stream_to_pdu_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
