options:
  parameters:
    author: Steven Knudsen
    copyright: AlbertaSat, 2023
    description: A program that accepts UDP packets containing complete ESTTC commands, modulates them, and transmits.
    generate_options: qt_gui
    id: ns_esttc_transmitter
    output_language: python
    title: Northern SPIRIT ESTTC command transmitter
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: fm_samples_per_symbol
  id: variable
  parameters:
    value: '100'
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud*fm_samples_per_symbol
  states: {}
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*math.pi*freq_dev/baud/fm_samples_per_symbol
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '32768'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhf_pdu_modulate_0
  id: uhf_pdu_modulate
  parameters:
    FSK_level: '2'
    fm_baud: baud
    fm_modulation_index: '.5'
    fm_samples_per_symbol: '256'
  states: {}

connections:
- [blocks_socket_pdu_1, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_1, pdus, uhf_pdu_modulate_0, pdus]
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [uhf_pdu_modulate_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
