options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: ns_esttc_receiver_file_save
    output_language: python
    title: Northern SPIRIT Ground Station received signal read from file
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '{es_mode == 0: 1200, es_mode==1: 2400, es_mode==2:4800,es_mode==3:9600,es_mode==4:9600}.get(True,19200)'
  states: {}
- name: data_rate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Data Rate
    type: int
    value: data_rate
  states: {}
- name: es_mode
  id: variable
  parameters:
    comment: |-
      EnduroSat Mode
        = [0,1,2,3,4,5,6,7]

      Choose a value before
      running this flowgraph
    value: '4'
  states: {}
- name: es_mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'EnduroSat UHF II Mode : '
    type: int
    value: es_mode
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '{es_mode == 0: 600, es_mode==1: 600, es_mode==2:1200,es_mode==3:2400,es_mode==4:4800,es_mode==5:4800,es_mode==6:9600}.get(True,19200)'
  states: {}
- name: freq_dev_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Dev
    type: int
    value: freq_dev
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '{es_mode == 0: 1, es_mode==1: 0.5, es_mode==2:0.5,es_mode==3:0.5,es_mode==4:1,es_mode==5:0.5,es_mode==6:1}.get(True,2)'
  states: {}
- name: mod_index_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: Mod Index
    type: real
    value: mod_index
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sensitivity_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: FM Sensitivity
    type: real
    value: sensitivity_tx
  states: {}
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*np.math.pi*(freq_dev/(data_rate*samples_per_symbol))
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/Michael/test_three_commands.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Command Response PDUs
      are passed to the ground
      station software for 
      processing.
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Beacon Info:

      Extract info from decoded AX.25 beacon

      Note : This is a hack, no error checking or other proper stuff...
      """

      import numpy as np
      from gnuradio import gr

      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Extract Beacon Info"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Beacon Info',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)



          def handle_msg(self, msg):
        
              msg_data = pmt.cdr(msg)
              parray = pmt.to_python(msg_data)
              destCallSign = ""
              raw = parray[0:6]
              for asc in raw:
                  destCallSign += chr(asc)
                  
              srcCallSign = ""
              raw = parray[7:7+6]
              for asc in raw:
                  srcCallSign += chr(asc)

              payload = ""
              parrayLen = len(parray)
              raw = parray[16:parrayLen]
              for asc in raw:
                  payload += chr(asc)
                  
              print("Raw data : ")
              print(msg_data)
              print("Dest Call Sign : "+destCallSign)
              print("Src Call Sign : "+srcCallSign)
              print("Payload : "+payload)
              
          def work(self, input_items, output_items):
                  return (0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Variables to be set
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated variables
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,3
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,3,1,2
    type: complex
  states: {}
- name: uhf_pdu_demodulate_0
  id: uhf_pdu_demodulate
  parameters:
    baud_rate: data_rate
    fm_modulation_index: mod_index
    fm_samples_per_symbol: samples_per_symbol
    packet_sync_word: '''10101010101010100111111010000000'''
    pdu_nominal_length: '128'
    squelch_threshold: '-10'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', uhf_pdu_demodulate_0, '0']
- [uhf_pdu_demodulate_0, beacons, epy_block_0, msg_in]
- [uhf_pdu_demodulate_0, pdus, blocks_message_debug_0, print]
- [uhf_pdu_demodulate_0, pdus, blocks_socket_pdu_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
