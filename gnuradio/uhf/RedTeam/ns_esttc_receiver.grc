options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: ns_esttc_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_rx
  id: variable
  parameters:
    comment: |-
      Carrier frequency
      corrected for doppler
      shift by GPredict
    value: '437875000'
  states: {}
- name: center_freq_tx
  id: variable
  parameters:
    comment: |-
      Calculated Tx carrier
      frequency
    value: int(2 * center_freq - center_freq_rx)
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '{es_mode == 0: 1200, es_mode==1: 2400, es_mode==2:4800,es_mode==3:9600,es_mode==4:9600}.get(True,19200)'
  states: {}
- name: data_rate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Data Rate
    type: int
    value: data_rate
  states: {}
- name: es_mode
  id: variable
  parameters:
    comment: |-
      EnduroSat Mode
        = [0,1,2,3,4,5,6,7]

      Choose a value before
      running this flowgraph
    value: '0'
  states: {}
- name: es_mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'EnduroSat UHF II Mode : '
    type: int
    value: es_mode
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '{es_mode == 0: 600, es_mode==1: 600, es_mode==2:1200,es_mode==3:2400,es_mode==4:4800,es_mode==5:4800,es_mode==6:9600}.get(True,19200)'
  states: {}
- name: freq_dev_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Dev
    type: int
    value: freq_dev
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '{es_mode == 0: 1, es_mode==1: 0.5, es_mode==2:0.5,es_mode==3:0.5,es_mode==4:1,es_mode==5:0.5,es_mode==6:1}.get(True,2)'
  states: {}
- name: mod_index_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: Mod Index
    type: real
    value: mod_index
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sensitivity_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: FM Sensitivity
    type: real
    value: sensitivity_tx
  states: {}
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*np.math.pi*(freq_dev/(data_rate*samples_per_symbol))
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshold
    start: '-50'
    step: '1'
    stop: '50'
    value: '-30'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 1, ''mask'': 1}))'
    period: '10000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''CTRL'', ''value'': 1, ''mask'': 0xFFFF}))'
    period: '7000'
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''DDR'', ''value'': 0x0FFF, ''mask'': 0xFFFF}))'
    period: '8000'
  states: {}
- name: blocks_message_strobe_0_1
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_0X'', ''value'': 0, ''mask'': 1}))'
    period: '8500'
  states: {}
- name: blocks_message_strobe_0_1_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_RX'', ''value'': 0, ''mask'': 1}))'
    period: '9000'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq_rx
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Variables to be set
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated variables
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dev_args: '""'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhf_pdu_demodulate_0
  id: uhf_pdu_demodulate
  parameters:
    baud_rate: data_rate
    fm_modulation_index: mod_index
    fm_samples_per_symbol: samples_per_symbol
    packet_sync_word: '''01111110'''
    pdu_nominal_length: '128'
    squelch_threshold: threshold
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0_0, command]
- [blocks_message_strobe_0_0, strobe, uhd_usrp_source_0_0, command]
- [blocks_message_strobe_0_0_0, strobe, uhd_usrp_source_0_0, command]
- [blocks_message_strobe_0_1, strobe, uhd_usrp_source_0_0, command]
- [blocks_message_strobe_0_1_0, strobe, uhd_usrp_source_0_0, command]
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', uhf_pdu_demodulate_0, '0']
- [uhf_pdu_demodulate_0, '0', qtgui_time_sink_x_0, '0']
- [uhf_pdu_demodulate_0, '1', blocks_uchar_to_float_0, '0']
- [uhf_pdu_demodulate_0, pdus, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
