options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: Grant_F_sig_gen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    label: Signal Source
    label0: Constant zero
    label1: Cosine 1 kHz
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain [0,89.8]
    rangeType: int
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: '1000000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
