options:
  parameters:
    author: Josh Lazaruk
    copyright: AlbertaSat 2022-202x
    description: The basic UHF modulation block
    generate_options: hb
    id: uhf_mode5_pdu_modulate
    output_language: python
    title: UHF Mode 5 PDU Moduliate
  states: {}

blocks:
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: spsym_frontend
    sensitivity: sensitivity_tx
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: sensitivity_tx
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: spsym_frontend
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', pad_sink_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.9.7.0
