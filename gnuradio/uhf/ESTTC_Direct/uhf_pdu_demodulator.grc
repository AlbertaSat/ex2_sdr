options:
  parameters:
    author: Josh Lazaruk, Steven Knudsen
    category: '[AlbertaSat]'
    copyright: AlbertaSat 2022-20xx
    description: The basic UHF demodulation block to match the EnduroSat II radio
    generate_options: hb
    id: uhf_pdu_demodulate
    output_language: python
    title: UHF PDU Demodulate
  states: {}

blocks:
- name: oversample_rate
  id: variable
  parameters:
    value: '8.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: fm_samples_per_symbol*baud_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Made QDemod Gain an if-then-else
      stmt to avoid div by zero
    gain: samp_rate/(2*math.pi*frequency_deviation) if frequency_deviation > 0 else samp_rate/(2*math.pi)
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud
    type: eng_float
    value: '9600'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.1'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: fm_samples_per_symbol
    ted_gain: '0.1'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: fm_modulation_index
  id: parameter
  parameters:
    label: FM Modulation Index
    type: eng_float
    value: '0'
  states: {}
- name: fm_samples_per_symbol
  id: parameter
  parameters:
    label: FM Samples per Symbol
    type: intx
    value: '128'
  states: {}
- name: frequency_deviation
  id: parameter
  parameters:
    type: eng_float
    value: '4800'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: packet_sync_word
  id: parameter
  parameters:
    label: Packet Sync (unpacked binary)
    type: str
    value: '''0111111010000000'''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdus
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: beacons
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_nominal_length
  id: parameter
  parameters:
    label: Nominal PDU length (bytes)
    type: intx
    value: '128'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: fm_samples_per_symbol*2
    samp_rate: samp_rate
    sym_rate: baud_rate*2
    type: fir_filter_fff
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: pdu_nominal_length
    sync: packet_sync_word
    threshold: int(len(packet_sync_word)/8)
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [pad_source_0, '0', satellites_fsk_demodulator_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_ax25_deframer_0, out, pad_sink_0_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, pad_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
