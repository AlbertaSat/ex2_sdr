options:
  parameters:
    author: knud
    generate_options: qt_gui
    id: ns_esttc_transmitter
    output_language: python
    title: Northern SPIRIT Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: center_freq_rx
  id: variable
  parameters:
    comment: |-
      Carrier frequency
      corrected for doppler
      shift by GPredict
    value: '437875000'
  states: {}
- name: center_freq_tx
  id: variable
  parameters:
    comment: |-
      Calculated Tx carrier
      frequency
    value: int(2 * center_freq - center_freq_rx)
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '{es_mode == 0: 1200, es_mode==1: 2400, es_mode==2:4800,es_mode==3:9600,es_mode==4:9600}.get(True,19200)'
  states: {}
- name: data_rate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: Data Rate
    type: int
    value: data_rate
  states: {}
- name: es_mode
  id: variable
  parameters:
    comment: |-
      EnduroSat Mode
        = [0,1,2,3,4,5,6,7]

      Choose a value before
      running this flowgraph
    value: '4'
  states: {}
- name: es_mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'EnduroSat UHF II Mode : '
    type: int
    value: es_mode
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '{es_mode == 0: 600, es_mode==1: 600, es_mode==2:1200,es_mode==3:2400,es_mode==4:4800,es_mode==5:4800,es_mode==6:9600}.get(True,19200)'
  states: {}
- name: freq_dev_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Dev
    type: int
    value: freq_dev
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '{es_mode == 0: 1, es_mode==1: 0.5, es_mode==2:0.5,es_mode==3:0.5,es_mode==4:1,es_mode==5:0.5,es_mode==6:1}.get(True,2)'
  states: {}
- name: mod_index_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: Mod Index
    type: real
    value: mod_index
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '256'
  states: {}
- name: sensitivity_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: FM Sensitivity
    type: real
    value: sensitivity_tx
  states: {}
- name: sensitivity_tx
  id: variable
  parameters:
    value: 2*np.math.pi*(freq_dev/(data_rate*samples_per_symbol))
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Normalized gain value Gain (dB) = 89.8*tx_gain
      For the UofA Ground Station amplifier,
      a setting of 0.5 to 0.56 will result in
      close to max power out (44 dBm). Any
      higher setting results in unacceptable 
      signal distortion.
    label: tx_gain
    start: '0'
    step: '0.05'
    stop: '0.6'
    value: '.4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: TX set GPIO0 High
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 0x1, ''mask'': 0x1}))'
    period: '3000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    comment: All GPIOs to ATR Mode
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''CTRL'', ''value'': 0xFFFF, ''mask'': 0xFFFF}))'
    period: '2000'
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    comment: All GPIOs are outputs
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''DDR'', ''value'': 0xFFFF, ''mask'': 0xFFFF}))'
    period: '2200'
  states: {}
- name: blocks_message_strobe_0_1
  id: blocks_message_strobe
  parameters:
    comment: Idle (flowgraph not running) set all Low
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_0X'', ''value'': 0x00, ''mask'': 0xFF}))'
    period: '2400'
  states: {}
- name: blocks_message_strobe_0_1_0
  id: blocks_message_strobe
  parameters:
    comment: RX set GPIO0-3, 5-7 Low
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_RX'', ''value'': 0, ''mask'': 0xEF}))'
    period: '2800'
  states: {}
- name: blocks_message_strobe_0_1_1
  id: blocks_message_strobe
  parameters:
    comment: RX set GPIO4 High
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_RX'', ''value'': 0x10, ''mask'': 0x10}))'
    period: '2600'
  states: {}
- name: blocks_message_strobe_0_1_2
  id: blocks_message_strobe
  parameters:
    comment: TX set GPIO1 - GPIO7 Low
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_TX'', ''value'': 0xFE, ''mask'': 0xFE}))'
    period: '3200'
  states: {}
- name: blocks_message_strobe_0_1_4
  id: blocks_message_strobe
  parameters:
    comment: |-
      Full Duplex required when
      operating RX and TX, 
      so XX mode sets GPIO0 High
    msg: 'pmt.dict_add( pmt.make_dict(), pmt.to_pmt(''gpio''), pmt.to_pmt({''bank'':''FP0'', ''attr'':''ATR_XX'', ''value'': 0x1, ''mask'': 0x1}))'
    period: '3400'
  states: {}
- name: gpredict_doppler_1
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq_tx
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhf_pdu_modulate_0
  id: uhf_pdu_modulate
  parameters:
    FSK_level: '2'
    fm_baud: data_rate
    fm_modulation_index: mod_index
    fm_samples_per_symbol: samples_per_symbol
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_0, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_0_0, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_1, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_1_0, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_1_1, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_1_2, strobe, uhd_usrp_sink_0_0, command]
- [blocks_message_strobe_0_1_4, strobe, uhd_usrp_sink_0_0, command]
- [network_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_0, pdus, uhf_pdu_modulate_0, pdus]
- [uhf_pdu_modulate_0, '0', qtgui_freq_sink_x_0, '0']
- [uhf_pdu_modulate_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
