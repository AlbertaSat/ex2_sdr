options:
  parameters:
    author: Daniel Estevez
    description: K2SAT S-band image decoder
    generate_options: qt_gui
    id: k2sat_image
    output_language: python
    title: K2SAT S-band image decoder
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: (int)(2.428e9)
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707-0.707j, 0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(samp_per_sym),0.35,11*samp_per_sym*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_bit*(samp_per_sym/2)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '"0101010101111110"'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-18'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/josh/git/ex2_sdr/gnuradio_sband/decodeddata.bin
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: baud_bit
    target: baud_bit
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: center_freq
    target: center_freq
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2, 3]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_extended_decoder_0_0_1
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: gpredict_doppler
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nfrom gnuradio import gr\nimport threading\nimport time\nimport socket\n\nclass doppler_runner(threading.Thread):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    threading.Thread.__init__(self)\n\n    self.callback = callback\n    self.gpredict_host = gpredict_host\n    self.gpredict_port = gpredict_port\n    self.freq = freq\n\n\n  def run(self):\n    #bind_to = (self.gpredict_host, self.gpredict_port)\n    bind_to = ('127.0.0.1', 4532)\n    server = socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n    print(bind_to)\n    server.bind(bind_to)\n    server.listen(0)\n\n    time.sleep(0.5) # TODO: Find better way to know if init is all done\n\n    while True:\n      print(\"Waiting for connection on: %s:%d\" % bind_to)\n      sock, addr = server.accept()\n      print(\"Connected from: %s:%d\" % (addr[0], addr[1]))\n\n      cur_freq = 0\n      while True:\n        data = sock.recv(1024)\n        if not data:\n          break\n\n        if data.startswith(b'F'):\n          self.freq = int(data[1:].strip())\n          if cur_freq != self.freq:\n            print(\"New frequency: %d\" % self.freq)\n            self.callback(self.freq)\n            cur_freq = self.freq\n          sock.sendall(b'RPRT 0\\n')\n        elif data.startswith(b'f'):\n          sock.sendall(b'f: %d\\n' % cur_freq)\n\n      sock.close()\n      print(\"Disconnected from: %s:%d\" % (addr[0], addr[1]))\n\n    #sys.exit()\n\nclass doppler(gr.sync_block):\n  def __init__(self, callback, freq, gpredict_host, gpredict_port):\n    gr.sync_block.__init__(self,\n                           name = \"Gpredict Doppler\",\n                           in_sig = None,\n                           out_sig = None)\n    doppler_runner(callback, freq, gpredict_host, gpredict_port).start()\n\n"
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: center_freq
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: After costas
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 6e6
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: window.WIN_HAMMING
    ymax: '50'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    size: '200'
    srate: samp_rate
    style1: '0'
    type: complex
    update_time: '0.2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '200'
    srate: samp_rate/samp_per_sym
    style1: '0'
    type: float
    update_time: '0.2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1'
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0_0_1
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '50'
    sync: '''11011010110110110000110100111101'''
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_1_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '50'
    sync: '''10111100101100001101101101011011'''
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_1_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '50'
    sync: '''11010110011111111110000011101'''
    threshold: '0'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', satellites_rms_agc_0, '0']
- [blocks_char_to_float_0, '0', fec_extended_decoder_0_0_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_simple_squelch_cc_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_costas_loop_cc_1, '0']
- [blocks_multiply_const_vxx_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_1, '0']
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_costas_loop_cc_1, '0', blocks_null_sink_0, '0']
- [digital_costas_loop_cc_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_diff_decoder_bb_0_1, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0_1, '0', satellites_descrambler308_0, '0']
- [digital_diff_decoder_bb_0_1, '0', satellites_sync_to_pdu_packed_0_0_1_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_1, '0', blocks_char_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_null_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [fec_extended_decoder_0_0_1, '0', digital_diff_decoder_bb_0_1, '0']
- [satellites_descrambler308_0, '0', blocks_char_to_float_1, '0']
- [satellites_descrambler308_0, '0', satellites_sync_to_pdu_packed_0_0_1, '0']
- [satellites_descrambler308_0, '0', satellites_sync_to_pdu_packed_0_0_1_0, '0']
- [satellites_rms_agc_0, '0', digital_costas_loop_cc_1, '0']
- [satellites_sync_to_pdu_packed_0_0_1, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0_1_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0_1_0_0, out, blocks_socket_pdu_0, pdus]
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [uhd_usrp_source_0, '0', digital_costas_loop_cc_1, '0']

metadata:
  file_format: 1
