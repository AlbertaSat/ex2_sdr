options:
  parameters:
    author: zergling
    generate_options: qt_gui
    id: S_band
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decode_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: good_length_8m
  id: variable
  parameters:
    value: int(32e6)
  states: {}
- name: good_start_10m
  id: variable
  parameters:
    value: int(104e6)
  states: {}
- name: good_start_8m
  id: variable
  parameters:
    value: int(76e6)
  states: {}
- name: good_start_noscram
  id: variable
  parameters:
    value: int(16e6)
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.8e6
    gain: '1'
    samp_rate: samp_rate
    width: 40e3
    win: window.WIN_HAMMING
  states: {}
- name: msg_sync
  id: variable
  parameters:
    value: '"0101010101010101"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.1415926'
  states: {}
- name: rate
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: 10e3
    stop: 500e3
    value: 10e3
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: short_len
  id: variable
  parameters:
    value: int(8192*64)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: stx_sync
  id: variable
  parameters:
    value: '"11010110011111111110000011101"'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {state: disabled}
- name: taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zergling/Downloads/output.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zergling/Downloads/usrp_samples [Attempt 4 - 2Mbps, 8Msps, Scrambler Off, 60dB attenuation].dat
    length: good_length_8m
    offset: good_start_noscram
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/zergling/Downloads/usrp_samples [Attempt 2.1 - 2Mbps, 10Msps].dat
    length: int(50e6)
    offset: good_start_10m
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'False'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"stx_sync"'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/20
    type: complex
  states: {}
- name: blocks_throttle_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_2_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: rate
    type: complex
  states: {state: bypassed}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: stx_sync
    tagname: '"stx_sync"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pi/50
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1'
    loop_bw: 2*pi*0.04
    max_dev: pi/2
    nfilters: 11*sps
    osps: '1'
    pfb_mf_taps: taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decode_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    xmax: '1.1'
    xmin: '-1.1'
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    ymax: '80'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    ymax: '80'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,2
    label1: Soft Bits Re
    label2: Soft Bits Im
    label3: Error
    label4: Instantaneous Period
    label5: Average Period
    label6: (unused)
    marker1: '1'
    marker2: '0'
    name: Symbol Synched Output and Debug
    nconnections: '3'
    size: '256'
    srate: samp_rate/sps
    style6: '0'
    tr_delay: '0.01'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"time_est"'
    type: complex
    update_time: '0.1'
    ymax: sps+2
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '512'
    srate: rate
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate/sps
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filt_fft
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: raw_fft
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filt_fft
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: raw_fft
  states: {state: disabled}

connections:
- [analog_agc_xx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '1']
- [blocks_float_to_complex_1_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '2']
- [blocks_interleave_0, '0', fec_extended_decoder_0, '0']
- [blocks_interleave_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_throttle_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_2_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [blocks_throttle_2_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_throttle_2_0_0, '0', qtgui_time_sink_x_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_throttle_2_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_throttle_2_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_diff_decoder_bb_0, '0', satellites_descrambler308_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '1', blocks_float_to_complex_0_0, '0']
- [digital_symbol_sync_xx_0, '2', blocks_float_to_complex_0_0, '1']
- [digital_symbol_sync_xx_0, '3', blocks_float_to_complex_1_0, '0']
- [fec_extended_decoder_0, '0', digital_diff_decoder_bb_0, '0']
- [filter_fft_rrc_filter_0, '0', analog_agc_xx_0_0, '0']
- [satellites_descrambler308_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
