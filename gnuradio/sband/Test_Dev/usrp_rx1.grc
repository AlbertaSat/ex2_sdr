options:
  parameters:
    author: Daniel Estevez
    description: K2SAT S-band image decoder
    generate_options: qt_gui
    id: k2sat_image
    output_language: python
    title: K2SAT S-band image decoder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.228e9
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_cc_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(samp_per_sym),0.35,11*samp_per_sym*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '"0101010101111110"'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-18'
  states: {state: bypassed}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: After costas
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 6e6
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: window.WIN_HAMMING
    ymax: '50'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    size: '200'
    srate: samp_rate
    style1: '0'
    type: complex
    update_time: '0.2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {state: bypassed}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1'
  states: {state: bypassed}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '2200'
    sync: '''0101010101111110'''
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '2200'
    sync: '''0101010101111110'''
    threshold: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', satellites_rms_agc_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_interleave_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_interleave_0_0, '1']
- [blocks_interleave_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_interleave_0_0, '0', fec_extended_decoder_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_simple_squelch_cc_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_diff_decoder_bb_0, '0', satellites_descrambler308_0, '0']
- [digital_diff_decoder_bb_0_0, '0', satellites_sync_to_pdu_packed_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [fec_extended_decoder_0_0, '0', digital_diff_decoder_bb_0, '0']
- [fec_extended_decoder_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [satellites_descrambler308_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [satellites_rms_agc_0, '0', digital_costas_loop_cc_1, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0_0, out, blocks_socket_pdu_0, pdus]
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
