options:
  parameters:
    author: zergling
    generate_options: qt_gui
    id: S_band
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable_qtgui_range
  parameters:
    start: pi*0.001
    step: pi*0.001
    stop: 2*pi
    value: 2*pi*0.04
  states: {state: disabled}
- name: clock
  id: variable_qtgui_range
  parameters:
    start: '0.5'
    step: '0.0005'
    stop: '1.5'
    value: '1'
  states: {state: disabled}
- name: constel_rx
  id: variable_constellation
  parameters:
    precision: '8'
    soft_dec_lut: '''auto'''
    type: qpsk
  states: {}
- name: constel_tx
  id: variable_constellation
  parameters:
    precision: '8'
    soft_dec_lut: '''auto'''
    type: qpsk
  states: {}
- name: decode_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '40'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: decode_1
  id: variable_cc_decoder_def
  parameters:
    framebits: '40'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: encode_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '40'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '128'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.0005'
    stop: '1'
    value: '0.05'
  states: {state: disabled}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.0005'
    stop: '0.5'
    value: '0'
  states: {state: disabled}
- name: pi
  id: variable
  parameters:
    value: '3.1415926'
  states: {}
- name: rate
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: 10e3
    stop: 500e3
    value: samp_rate/4
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: ted_g
  id: variable_qtgui_range
  parameters:
    start: '0.0005'
    step: '0.0005'
    stop: '2'
    value: '1.0'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zergling/Downloads/test_input_multiple.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_2_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.05'
    freq_offset: '0.01'
    noise_voltage: '0.05'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel_tx
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel_rx
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel_rx
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pi/250
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {state: disabled}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel_rx
    damping: '1.0'
    loop_bw: 2*pi*0.02
    max_dev: pi/2
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '2.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decode_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decode_1
    puncpat: '''11'''
    threadtype: none
  states: {state: disabled}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: encode_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*sps
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    type: complex
    ymax: '30'
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '512'
    srate: rate
    type: float
    ymax: '256'
    ymin: '-256'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,2
    label1: Error
    label2: Inst_T
    label3: Avg_T
    label4: ''
    name: Symbol Synched Output and Debug
    nconnections: '2'
    size: '256'
    srate: samp_rate/sps
    tr_delay: '0.01'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"time_est"'
    type: complex
    update_time: '0.1'
    ymax: sps+2
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '512'
    srate: rate
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: satellites_hexdump_sink_0_0_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '12'
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '12'
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_1
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '12'
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filt_fft
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filt_fft
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', blocks_throttle_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [blocks_float_to_complex_1_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_throttle_2, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_1, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_2, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_throttle_2_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_throttle_2_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', satellites_sync_to_pdu_packed_0_0_0, '0']
- [channels_channel_model_0, '0', satellites_rms_agc_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_modulator_0, '0', filter_fft_rrc_filter_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', fec_extended_decoder_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_extended_decoder_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_descrambler_bb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_descrambler_bb_0_0, '0', satellites_sync_to_pdu_packed_0_0_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_descrambler_bb_0_0, '0']
- [digital_diff_encoder_bb_0, '0', fec_extended_encoder_0, '0']
- [digital_scrambler_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_throttle_2_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_1, '0']
- [digital_symbol_sync_xx_0, '1', blocks_float_to_complex_0_0, '0']
- [digital_symbol_sync_xx_0, '2', blocks_float_to_complex_0_0, '1']
- [digital_symbol_sync_xx_0, '3', blocks_float_to_complex_1_0, '0']
- [fec_extended_decoder_0, '0', digital_diff_decoder_bb_0, '0']
- [fec_extended_decoder_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_1, '0']
- [filter_fft_rrc_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', channels_channel_model_0, '0']
- [satellites_rms_agc_0, '0', digital_costas_loop_cc_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, satellites_hexdump_sink_0_0_0_0, in]
- [satellites_sync_to_pdu_packed_0_0_0, out, satellites_hexdump_sink_0_0_0_0, in]
- [satellites_sync_to_pdu_packed_0_0_1, out, satellites_hexdump_sink_0_0_0_0, in]
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
